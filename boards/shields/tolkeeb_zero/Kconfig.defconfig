## boards/shields/tolkeeb_zero/Kconfig.defconfig
```kconfig
if SHIELD_TOLKEEB_ZERO

config ZMK_KEYBOARD_NAME
    default "Tolkeeb Zero"

endif
```
